# Keil uVision project fsmc.uvprojx, settings and files
target STM32F100VC (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F100VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00006000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: fsmc +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\FW;.\CMSIS\Inc;.\USER\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Startup
    ./Startup/: startup_stm32f100xe.s
  group CMSIS
    ./CMSIS/Src/: system_stm32f1xx.c
  group USER
    ./USER/src/: main.c GPIO_init.c RCC_init.c TIM_init.c GPIO_func.c USART1.c USART2.c
